options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio1
  id: variable_qtgui_range
  parameters:
    label: Squelch1
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio2
  id: variable_qtgui_range
  parameters:
    label: Squelch2
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    label: audio_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10'
    value: '5'
  states: {}
- name: freq1
  id: variable
  parameters:
    value: 1.17e6
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 0.76e6
  states: {}
- name: freq_center
  id: variable_qtgui_entry
  parameters:
    label: freq_center
    type: real
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.0e6
  states: {}
- name: xlate_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 125000, 25000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '.7'
    type: complex
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: 48e3
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-audio1'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-audio2'
    type: complex
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: int(samp_rate/62500)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1500'
    win: firdes.WIN_HAMMING
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    ant0: '0'
    args: hackrf=0
    bb_gain0: '0'
    bw0: '10000000'
    freq0: freq_center
    gain0: '41'
    gain_mode0: 'True'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_center
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq1
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '625'
    fbw: '0.4'
    interp: '480'
    taps: ''
    type: ccc
  states: {}
- name: xlating_fir_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq1-freq_center
    decim: '1'
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}
- name: xlating_fir_filter_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq2-freq_center
    decim: '1'
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_am_demod_cf_0_0, '0']
- [analog_am_demod_cf_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_add_xx_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [osmosdr_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0_0, '0', xlating_fir_filter, '0']
- [osmosdr_source_0_0, '0', xlating_fir_filter_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_agc3_xx_0, '0']
- [xlating_fir_filter, '0', analog_pwr_squelch_xx_0, '0']
- [xlating_fir_filter_0, '0', analog_pwr_squelch_xx_0_0, '0']

metadata:
  file_format: 1
