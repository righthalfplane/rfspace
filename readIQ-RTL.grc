options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 101.5e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 101.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: xlate_filter_taps
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 100000, 20000)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: '240000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/dir/Desktop/iqComplex.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/dir/Desktop/iqByte.raw
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: gr_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '2000000'
    fbw: '0.4'
    interp: '240000'
    taps: ''
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: xlating_fir_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq-center_freq
    decim: '1'
    samp_rate: samp_rate
    taps: xlate_filter_taps
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', gr_multiply_const_vxx_1, '0']
- [blocks_file_source_0, '0', blocks_null_sink_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0_0, '0', blocks_null_sink_0_1, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_null_sink_0_0_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', xlating_fir_filter, '0']
- [gr_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [gr_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_null_sink_0, '0']
- [xlating_fir_filter, '0', qtgui_freq_sink_x_0, '0']
- [xlating_fir_filter, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
