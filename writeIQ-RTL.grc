options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 101.5e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 101.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/dir/Desktop/iqComplex.raw
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/dir/Desktop/iqByte.raw
    type: byte
    unbuffered: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
